# Keil uVision project Project.uvprojx, settings and files
target BSY_BUTTON_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BSY_BUTTON_Test +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\LIB\inc;..\CMSIS;..\BSP\USART;..\BSP\STMFLASH;..\BSP\sys;..\BSP\WDG;..\BSP\BSY_OS;..\BSP\LED;..\BSP\MALLOC;..\BSP\BSY_BUS;..\BSP\RS485;..\BSP\BSY_BUTTON;..\BSP\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/STMFLASH/: stmflash.c
    ../BSP/sys/: sys.c
    ../BSP/WDG/: wdg.c
    ../BSP/BSY_OS/: bsy_os.c
    ../BSP/LED/: Led.c
    ../BSP/MALLOC/: malloc.c
    ../BSP/BSY_BUS/: bsy_bus.c
    ../BSP/RS485/: rs485.c
    ../BSP/BSY_BUTTON/: bsy_button.c
    ../BSP/KEY/: key.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_iwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_md.s
